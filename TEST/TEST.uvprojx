# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Inc;.\User;.\Drivers;.\Hardware;.\System;.\FreeRTOS_CORE;.\FreeRTOS_PORT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_it.h
  group CMSIS
    ./CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c core_cm4.h core_cmInstr.h arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cmSimd.h core_sc000.h core_sc300.h core_cmFunc.h
  group Inc
    ./Inc/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group Drivers
    ./Drivers/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/: ws2812.c ws2812.h
  group System
    ./System/: Delay.c Delay.h
  group FreeRTOS_CORE
    ./FreeRTOS_CORE/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c croutine.h event_groups.h FreeRTOS.h list.h queue.h task.h timers.h projdefs.h portable.h deprecated_definitions.h mpu_wrappers.h stream_buffer.h stack_macros.h
  group FreeRTOS_PORT
    ./FreeRTOS_PORT/: heap_4.c port.c portmacro.h
